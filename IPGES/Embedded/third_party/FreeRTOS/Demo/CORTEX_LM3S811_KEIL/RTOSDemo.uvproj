# Keil uVision project RTOSDemo.uvproj, settings and files
target FreeRTOS_Demo (ARM-ADS)
  device: LM3S811 Luminary Micro
  cpu: IRAM(0x20000000-0x20001fff) IROM(0-0xffff) CLOCK(50000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo
  c flags: Optim=2 OneElfS=1
  c define: RVDS_ARMCM3_LM3S102
  c include: .;./LuminaryCode;..\..\Source\portable\RVDS\ARM_CM3;..\..\Source\include;..\Common\include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler --last xHeap
  group Demo_Source
    ./: startup_rvmdk.S main.c
    ./LuminaryCode/: osram96x16.c
    ../Common/Minimal/: semtest.c integer.c PollQ.c BlockQ.c
    ./heap/: heap_1.c
  group Libraries
    ../Common/drivers/LuminaryMicro/keil/: driverlib.lib
  group RTOS_Source
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
  group Documentation
    ./: readme.txt
